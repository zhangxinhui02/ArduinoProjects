# Keil uVision project BKM-51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: BKM-51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\IIC_OLED
  group Source Group 1
    ./: mian.c
    ./IIC_OLED/: oled.c
