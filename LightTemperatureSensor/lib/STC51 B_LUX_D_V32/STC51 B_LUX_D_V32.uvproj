# Keil uVision project STC51 B_LUX_D_V32.uvproj, settings and files
target B_LUX_D_V32 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: STC51 B_LUX_D_V32 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib
  group user
    ./: STARTUP.A51 main.c
  group lib
    ./lib/: Delay.c B_LUX_V32.c
