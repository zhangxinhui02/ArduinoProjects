# Keil uVision project gpio.uvprojx, settings and files
target gpio (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: gpio +hex
  c flags: Optim=1
  c include: ..\CMSIS\Device\ST\STM32F4xx\Include;..\CMSIS\Include;..\Lib\inc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group CMSIS
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Lib
    ../Lib/src/: Led.c sys.c SysTick.c B_LUX_V32D.c
  group User
    ../User/: main.c
